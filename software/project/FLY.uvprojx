# Keil uVision project FLY.uvprojx, settings and files
target FLY (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FLY +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_USB_OTG_FS,USE_EMBEDDED_PHY
  c include: ..\src\main;..\src\drivers\interface;..\src\system\delay;..\src\system\sys;..\src\system\usart;..\lib\CMSIS\CoreSupport\Include;..\lib\CMSIS\DeviceSupport\ST\STM32F4xx\Include;..\lib\FreeRTOS\include;..\lib\FreeRTOS\port\RVDS\ARM_CM4F;..\lib\STM32F4xx_StdPeriph_Driver\inc;..\src\sensors\interface;..\src\math\interface;..\src\task\interface;..\src\control\interface
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MAIN
    ../src/main/: FreeRTOSConfig.h main.c system_stm32f4xx.c parameter.c flightStatus.c flightStatus.h messageQueue.c
  group TASK
    ../src/task/interface/: taskconfig.h
    ../src/task/src/: getsensor_task.c sensor_task.c navigation_task.c control_task.c
  group CONTROL
    ../src/control/src/: rc.c motor.c flightControl.c userControl.c
  group SENSORS
    ../src/sensors/src/: accelerometer.c barometer.c gyroscope.c magnetometer.c sensordata.c
  group MATH
    ../src/math/src/: pid.c LevenbergMarquardt.c mathtool.c lowpassfilter.c mahony.c quaternion.c matrix3.c vector3.c
  group DRIVERS
    ../src/drivers/src/: system.c pwm.c cppm.c led.c ws2812.c nvic.c soft_iic_gpio.c mpu9250.c bmp280.c flash.c beeper.c
  group SYSTEM
    ../src/system/delay/: delay.c
    ../src/system/sys/: sys.c
    ../src/system/usart/: usart.c
  group STARTUP
    ../lib/CMSIS/DeviceSupport/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group STM32F4xx_StdPeriph_Driver
    ../lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c
  group FreeRTOS/src
    ../lib/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../lib/FreeRTOS/port/MemMang/: heap_4.c
    ../lib/FreeRTOS/port/RVDS/ARM_CM4F/: port.c
